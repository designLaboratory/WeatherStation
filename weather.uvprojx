# Keil uVision project weather.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL46Z256xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IRAM(0x1FFFE000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: weather
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: main.c I2C.c LCD.c s401.c STLM75.c I2C.h LCD.h LCDConfig.h Main.h STLM75.h WS2812.c WS2812.h LPS331.c HTS221.c TSL25721.c transf.c SysTick.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
